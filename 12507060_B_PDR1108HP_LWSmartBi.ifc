Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-01-23T11:23:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 23 11:23:36 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\1ad053cd-0a06-4e03-94f6-5ba7aa3b7a36\94a7748c-07e0-43d0-bda7-d42819402ab8\ifc * Database version: 5507 * Database creation date: Tue Jan 23 11:23:35 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 23 11:23:35 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 23 11:23:35 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12507060_B_PDR1108HP_LWSmartBi:52110801_B_12507060_PDR1108HP_LWSmartBi, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 52110801_B_12507060_PDR1108HP_LWSmartBi
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 52110801_B_12507060_PDR1108HP_LWSmartBi
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Powder Coat_Grey, z_Miele_Design_Orange, z_Miele_Design_Glass, z_Miele_Design_Powder Coat_Lotus White, Polypropylene, z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, Default, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
